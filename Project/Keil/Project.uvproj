# Keil uVision project Project.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=2 wLevel=2
  c define: __BUILD_WITH_EXAMPLE__
  c include: ..\..\Core\CMSIS\Include;..\..\Core\Device\Include;..\..\Drivers\include;..\..\BoardSupport;..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\..\uCOS-II\Source;..\..\uCOS-II\Cfg;..\..\emWin\Config;..\..\emWin\GUI;..\..\emWin\SEGGERDEMO;..\..\Project;..\..\FatFS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Flash\Project.sct
  group Startup
    ../../Core/Device/Source/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../../Core/Device/Source/: system_LPC177x_8x.c
  group Drivers
    ../../Drivers/source/: lpc177x_8x_gpio.c lpc177x_8x_systick.c lpc177x_8x_clkpwr.c debug_frmwrk.c lpc177x_8x_adc.c lpc177x_8x_bod.c lpc177x_8x_can.c lpc177x_8x_crc.c lpc177x_8x_dac.c lpc177x_8x_eeprom.c lpc177x_8x_emac.c lpc177x_8x_emc.c lpc177x_8x_exti.c lpc177x_8x_gpdma.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_iap.c lpc177x_8x_lcd.c lpc177x_8x_mci.c lpc177x_8x_mcpwm.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_pwm.c lpc177x_8x_qei.c lpc177x_8x_rtc.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_wwdt.c lpc177x_8x_ssp.c
  group Main
    ../../BoardSupport/: main.c app.c list_of_boats.c T90.c stub.c bully.c snap.c xt_isd.c sound.c str.c check.c sdram.c dma.c lcd43.c timer.c uart.c pwm.c SPI1.c SPI2.c fish.c yu.c mao.c gg.c 16.c 24.c 28.c 30.c 120.c detect.c transform.c _T90_20.c _T90_40.c _T90_24.c _T90_30B.c _T90_60.c _T90_45B.c comm.c _T90_30.c
  group UI
    ../../BoardSupport/: logo.h T90Color.c dlg.c MainTask.c WinWorkMode.c WinMainShip.c DlgMainMenu.c DlgDstSetMenu.c DlgAlarmSetMenu.c DlgSystemSet.c DlgSpecialAlarmSet.c WinSingleShipDstSet.c WinDoubleShipDstSet.c WinInvdAlarmSet.c WinSpdingAlarmSet.c WinSogAlarmSet.c Winconfirm.c WinAlarmMonitor.c plot.c DispSOGNums.c WinHighSpeedShipSet.c WinMMSISet.c WinFleet.c
  group uCOS-II/Ports
    ../../uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
  group uCOS-II/Source
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group emWin/Config
    ../../emWin/Config/: GUI_X.c GUIConf.h GUIConf.c LCDConf.c LCDConf.h
  group emWin/GUI
    ../../emWin/GUI/: emWin_520_Keil460_M3_LE.lib
  group Readme
    ../../BoardSupport/: readme.txt
  group HSD_lib
    ../../BoardSupport/: HSD_SLIDER.c HSD_BUTTON.c HSD_GUI__SetText.c HSD_DIMENSION.c HSD_STICKFIGURE.c HSD_DIMENSION_EX.c HSD_Toast.c
target RAM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Project +hex
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__
  c include: ..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
